# Keil uVision project Simple_Waveform_Generator.uvprojx, settings and files
target STM_NUCLEO-F072RB (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F072RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Simple_Waveform_Generator
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Sources
    ./: main.c DAC_DRV.c GPIO_DRV.c TIMER_DRV.c Serial.c Retarget.c DMA_DRV.c WaveGen.c apptree.c
  group Includes
    ./: DAC_DRV.h GPIO_DRV.h TIMER_DRV.h DMA_DRV.h Serial.h WaveGen.h apptree.h list.h
software components: CMSIS:CORE 4.3.0, Device:Startup 1.5.0
